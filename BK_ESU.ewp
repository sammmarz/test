# IAR project BK_ESU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VE ST STM32L152VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L1XX_XL; USE_STDPERIPH_DRIVER; _DLIB_TIME_USES_64
  ICCARM.CCIncludePath2: ; _Import\CMSIS; _Import\FreeRTOS\inc; _Import\FreeRTOS\src; _Import\SPL\src; _Import\SPL\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BK_ESU.bin
  ILINK.IlinkOutputFile: BK_ESU.out
  ILINK.IlinkIcfFile: stm32l152xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32L1XX_XL; USE_STDPERIPH_DRIVER; _DLIB_TIME_USES_64
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Common.c Common.h crc16.c main.c reprogram.c reprogram.h
  group _Import/CMSIS
    _Import/CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32l1xx_xl.s stm32l1xx.h stm32l1xx_conf.h system_stm32l1xx.c system_stm32l1xx.h
  group _Import/FreeRTOS/inc
    _Import/FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group _Import/FreeRTOS/src
    _Import/FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c portasm.s queue.c stream_buffer.c tasks.c timers.c
  group _Import/SPL/inc
    _Import/SPL/inc/: misc.h stm32l1xx_adc.h stm32l1xx_aes.h stm32l1xx_comp.h stm32l1xx_crc.h stm32l1xx_dac.h stm32l1xx_dbgmcu.h stm32l1xx_dma.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_fsmc.h stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_iwdg.h stm32l1xx_lcd.h stm32l1xx_opamp.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_rtc.h stm32l1xx_sdio.h stm32l1xx_spi.h stm32l1xx_syscfg.h stm32l1xx_tim.h stm32l1xx_usart.h stm32l1xx_wwdg.h
  group _Import/SPL/src
    _Import/SPL/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group mdDataManager
    mdDataManager/: CheckProgramData.c CheckProgramData.h FormingArchives.c FormingPeriodCycleData.c mdDataManager.c mdDataManager.h
  group mdDebug
    mdDebug/: debugFunc.c flash.c
  group mdDisplay
    mdDisplay/: ConverterFunctions.c ConverterFunctions.h DisplayFunctions.c DisplayFunctions.h DisplayHardware.c DisplayHardware.h Fonts12x16.c Fonts12x16.h Fonts5x8.c Fonts5x8.h mdDisplay.c mdDisplay.h Navigate.c Navigate.h Screens_0.c Screens_1.c Screens_2.c Screens_3.c Screens_4.c StringsForDisplay.c StringsForDisplay.h StringsWarnings.c StringsWarnings.h
  group mdFlashMemory
    mdFlashMemory/: DataForFlash.c DataForFlash.h HardwareFlashMemory.c HardwareFlashMemory.h mdFlashMemory.c mdFlashMemory.h
  group mdFTP
    mdFTP/: driver_GL865.c driver_GL865.h mdFTP.c mdFTP.h
  group mdHall
    mdHall/: mdHall.c mdHall.h
  group mdHardware
    mdHardware/: GPIO.c I2C.c Interrupts.c mdHardware.h SPI_1.c SPI_2.c USART_1.c USART_3.c
  group mdLIS200
    mdLIS200/: ArchivesFunc.c Lis200func.c mdLis200.c mdLis200.h
  group mdModes
    mdModes/: mdModes.c mdModes.h
  group mdOpticalInterface
    mdOpticalInterface/: mdOpticalInterface.c mdOpticalInterface.h
  group mdPower
    mdPower/: mdPower.c mdPower.h
  group mdRTC
    mdRTC/: mdRTC.c mdRTC.h Watchdog.c
  group mdTemperSensor
    mdTemperSensor/: HardwareTemperSensor.c HardwareTemperSensor.h mcuTemperSensor.c mdTemperSensor.c mdTemperSensor.h
  group Params
    Params/: Access.c DescribedParams.c Events.c Events.h mdParams.c Params.h ParamsRange.c ParamsReadFunctions.c ParamsWriteFunctions.c
